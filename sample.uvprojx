# Keil uVision project sample.uvprojx, settings and files
target LandTiger_LPC1768 (release) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample_BUTTON_DE-BOUNCING
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c include: .\Source\button_EXINT;.\Source\CMSIS_core;.\Source\led;.\Source\RIT;.\Source
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./Source/: startup_LPC17xx.s
  group main
    ./Source/: sample.c maze.c game.c render.c ghost.c audio.c can.c
  group lib_SoC_board
    ./Source/: system_LPC17xx.c
  group led
    ./Source/led/: funct_led.c lib_led.c led.h
  group button_EINT
    ./Source/button_EXINT/: button.h IRQ_button.c lib_button.c
  group RIT
    ./Source/RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group CMSIS_core
    ./Source/CMSIS_core/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h mpu_armv7.h
  group timer
    ./Source/timer/: timer.h lib_timer.c IRQ_timer.c
  group JOYSTICK
    ./Source/joystick/: joystick.h lib_joystick.c
  group ADC
    ./Source/adc/: lib_adc.c adc.h IRQ_adc.c
  group GLCD
    ./Source/GLCD/: GLCD.c HzLib.c GLCD.h HzLib.h AsciiLib.h AsciiLib.c
  group TP
    ./Source/TouchPanel/: TouchPanel.c TouchPanel.h
target SW_Debug (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: sample_BUTTON_DE-BOUNCING
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c define: SIMULATOR
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 6.1.0
